options:
  parameters:
    author: Mictronics
    category: Custom
    comment: |-
      Modified version of Mictronics' ais-simulator.grc

      Sends bursts to a file instead of a radio.

      See msg1_example.grc as an example of how to
      generate the messages.

      Newer versions of GNU Radio can create a continuous
      IQ file using the Burst to Stream block.
    generate_options: no_gui
    id: top_block
    output_language: python
    run_options: run
    title: Example AIS Transmitter
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: ais_simulator_bitstring_to_frame_0
  id: ais_simulator_bitstring_to_frame
  parameters:
    enable_nrzi: 'True'
    len_tag_key: packet_len
  states: {}
- name: ais_simulator_websocket_pdu_0
  id: ais_simulator_websocket_pdu
  parameters:
    addr: 127.0.0.1
    comment: For use with ais-simulator web app.
    port: '52002'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/ais_bursts_1Msps.fc32
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.4'
    samples_per_symbol: int(samp_rate/bit_rate)
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:7070
    comment: |-
      For use with gr-pyais_toolkit. Convert messages
      with NMEA to AIS Simulator (bits) before sending
      via ZMQ.
    timeout: '100'
  states: {}

connections:
- [ais_simulator_bitstring_to_frame_0, '0', digital_gmsk_mod_0, '0']
- [ais_simulator_websocket_pdu_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [blocks_multiply_const_xx_0, '0', blocks_file_sink_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_const_xx_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', ais_simulator_bitstring_to_frame_0, '0']
- [zeromq_sub_msg_source_0, out, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: v3.10.11.0-64-g35346914
