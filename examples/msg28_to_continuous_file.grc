options:
  parameters:
    author: user
    comment: |-
      Generates continuous IQ containing a variety of
      Message 28 (Aid-to-Navigation Report, single-slot)
      bursts on top of noise, written to a file.

      Three AtoNs are simulated:
      - a virtual AtoN marking a navigation hazard
      - a physical floating port hand mark with a swing circle
      - a mobile AtoN reporting its COG/SOG vector,
      with a position that actually moves to match.

      Requires pyais 2.20.0+, gr-ais_simulator, and
      GNU Radio 3.10.11.0+ (Burst to Stream).
    generate_options: no_gui
    id: msg28_to_continuous_file
    output_language: python
    run_options: run
    title: AIS Message Type 28 to continuous IQ file
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: ais_simulator_bitstring_to_frame_0
  id: ais_simulator_bitstring_to_frame
  parameters:
    enable_nrzi: 'True'
    len_tag_key: packet_len
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '.05'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_burst_to_stream_0
  id: blocks_burst_to_stream
  parameters:
    len_tag_key: '"packet_len"'
    propagate_tags: 'False'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/msg28_continuous_1Msps.fc32
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(samp_rate/bit_rate)*128
    type: complex
  states: {}
- name: blocks_tag_gate_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.4'
    samples_per_symbol: int(samp_rate/bit_rate)
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pyais_toolkit_message_type_28_0
  id: pyais_toolkit_message_type_28
  parameters:
    aid_type: '39'
    auth: '0'
    charted_status: '0'
    comment: |-
      Virtual AtoN marking a
      navigation hazard.
    dimension: '0'
    dimension_additional_data: '0'
    dimensions_a: '0'
    dimensions_b: '0'
    iala_mrn: '10001'
    latitude: '0.0'
    longitude: '0.0'
    mmsi: '993381001'
    repeat: '0'
    restricted: '0'
    second: '60'
    station_status: '0'
    station_type: '4'
    status_bits: '0'
  states: {}
- name: pyais_toolkit_message_type_28_1
  id: pyais_toolkit_message_type_28
  parameters:
    aid_type: '20'
    auth: '0'
    charted_status: '1'
    comment: |-
      Physical floating port hand mark,
      charted, with a 150 m swing circle
      (dimension type 2: A in 100 m steps
      + B in 1 m steps).
    dimension: '2'
    dimension_additional_data: '0'
    dimensions_a: '1'
    dimensions_b: '50'
    iala_mrn: '10002'
    latitude: '0.0'
    longitude: '0.0'
    mmsi: '993381002'
    repeat: '0'
    restricted: '0'
    second: '60'
    station_status: '0'
    station_type: '0'
    status_bits: '0'
  states: {}
- name: pyais_toolkit_message_type_28_2
  id: pyais_toolkit_message_type_28
  parameters:
    aid_type: '36'
    auth: '0'
    charted_status: '0'
    comment: |-
      Mobile AtoN (towed object) reporting
      its vector (dimension type 3:
      A = COG 90 deg, B = SOG 4 kn).
      The strobe moves its position to match.
    dimension: '3'
    dimension_additional_data: '0'
    dimensions_a: '90'
    dimensions_b: '4'
    iala_mrn: '10003'
    latitude: '0.0'
    longitude: '0.0'
    mmsi: '993381003'
    repeat: '0'
    restricted: '0'
    second: '60'
    station_status: '1'
    station_type: '5'
    status_bits: '0'
  states: {}
- name: pyais_toolkit_nmea_to_nmea_bits_0
  id: pyais_toolkit_nmea_to_nmea_bits
  parameters: {}
  states: {}
- name: pyais_toolkit_strobe_latlon_moving_0
  id: pyais_toolkit_strobe_latlon_moving
  parameters:
    bearing: '0'
    comment: |-
      Fixed position (speed 0):
      hazard south of the channel.
    initial_delay: '0.0'
    interval: '3'
    lat_ref: '36.95'
    lon_ref: '-76.32'
    speed: '0'
  states: {}
- name: pyais_toolkit_strobe_latlon_moving_1
  id: pyais_toolkit_strobe_latlon_moving
  parameters:
    bearing: '0'
    comment: |-
      Fixed position (speed 0):
      buoy at the channel entrance.
    initial_delay: '1.0'
    interval: '5'
    lat_ref: '36.99'
    lon_ref: '-76.30'
    speed: '0'
  states: {}
- name: pyais_toolkit_strobe_latlon_moving_2
  id: pyais_toolkit_strobe_latlon_moving
  parameters:
    bearing: '90'
    comment: |-
      Moving east at 4 knots, matching
      the reported mobile AtoN vector.
    initial_delay: '2.0'
    interval: '2'
    lat_ref: '37.02'
    lon_ref: '-76.35'
    speed: '4'
  states: {}

connections:
- [ais_simulator_bitstring_to_frame_0, '0', digital_gmsk_mod_0, '0']
- [analog_fastnoise_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_burst_to_stream_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_tag_gate_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_burst_to_stream_0, '0']
- [blocks_tag_gate_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '1']
- [digital_gmsk_mod_0, '0', blocks_multiply_const_xx_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', ais_simulator_bitstring_to_frame_0, '0']
- [pyais_toolkit_message_type_28_0, nmea_list, pyais_toolkit_nmea_to_nmea_bits_0, nmea_list]
- [pyais_toolkit_message_type_28_1, nmea_list, pyais_toolkit_nmea_to_nmea_bits_0, nmea_list]
- [pyais_toolkit_message_type_28_2, nmea_list, pyais_toolkit_nmea_to_nmea_bits_0, nmea_list]
- [pyais_toolkit_nmea_to_nmea_bits_0, nmea_bits, pdu_pdu_to_tagged_stream_0, pdus]
- [pyais_toolkit_strobe_latlon_moving_0, latlon, pyais_toolkit_message_type_28_0, latlon]
- [pyais_toolkit_strobe_latlon_moving_1, latlon, pyais_toolkit_message_type_28_1, latlon]
- [pyais_toolkit_strobe_latlon_moving_2, latlon, pyais_toolkit_message_type_28_2, latlon]

metadata:
  file_format: 1
  grc_version: v3.10.11.0-64-g35346914
