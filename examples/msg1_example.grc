options:
  parameters:
    author: user
    comment: |-
      Run ais-simulator_to_burst_file.grc to generate an IQ
      file from these messages.

      This creates AIS messages of a vessel
      moving at 20 knots with a course and
      heading of 45 degrees starting at 38, -78.
    generate_options: qt_gui
    id: msg1_example
    output_language: python
    title: AIS Message Type 1 example
  states: {}

blocks:
- name: pyais_toolkit_message_type_1_0
  id: pyais_toolkit_message_type_1
  parameters:
    course: '45'
    heading: '45'
    latitude: '0.0'
    longitude: '0.0'
    mmsi: '338123456'
  states: {}
- name: pyais_toolkit_nmea_to_nmea_bits_0
  id: pyais_toolkit_nmea_to_nmea_bits
  parameters: {}
  states: {}
- name: pyais_toolkit_strobe_latlon_moving_0
  id: pyais_toolkit_strobe_latlon_moving
  parameters:
    bearing: '45'
    initial_delay: '0.0'
    interval: '.5'
    lat_ref: '38'
    lon_ref: '-75'
    speed: '20'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:7070
    timeout: '100'
  states: {}

connections:
- [pyais_toolkit_message_type_1_0, nmea_list, pyais_toolkit_nmea_to_nmea_bits_0, nmea_list]
- [pyais_toolkit_nmea_to_nmea_bits_0, nmea_bits, zeromq_pub_msg_sink_0, in]
- [pyais_toolkit_strobe_latlon_moving_0, latlon, pyais_toolkit_message_type_1_0, latlon]

metadata:
  file_format: 1
  grc_version: v3.10.11.0-64-g35346914
