options:
  parameters:
    author: michael morrison
    category: '[pyais_toolbox]/Hier'
    comment: |-
      https://wiki.gnuradio.org/index.php/Polymorphic_Types_(PMTs)

      A 'cons' is a pair consisting of a 'car' and 'cdr'.

      The pmt 'intern' is another way of saying 'string to pmt symbol'

      You must copy the resulting .py to ~/.grc_gnuradio
      https://wiki.gnuradio.org/index.php/Hier_Blocks_and_Parameters
    generate_options: hb
    id: ais_latlon_strobe
    output_language: python
    title: AIS LatLon Strobe
  states: {}

blocks:
- name: empty_dict
  id: variable
  parameters:
    value: pmt.make_dict()
  states: {}
- name: latitude_dict
  id: variable
  parameters:
    value: pmt.dict_add(empty_dict, pmt.intern("lat"), pmt.from_float(lat))
  states: {}
- name: latitude_longitude_dictionary
  id: variable
  parameters:
    value: pmt.dict_add(latitude_dict, pmt.intern("lon"), pmt.from_float(lon))
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: |-
      Sends a PDU which is a pmt.cons:
      - car: Metadata which is a dictionary
      - cdr: Data which is null (PMT_NIL)

      Metadata:
      - Dictionary contains two key:value pairs
    msg: pmt.cons(latitude_longitude_dictionary, pmt.PMT_NIL)
    period: '1000'
  states: {}
- name: lat
  id: parameter
  parameters:
    label: Latitude
    type: eng_float
    value: '30'
  states: {}
- name: lon
  id: parameter
  parameters:
    label: Longitude
    type: eng_float
    value: '-100'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: latlon
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: latlon
    optional: 'True'
    type: message
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pad_sink_0, in]
- [pad_source_0, out, blocks_message_strobe_0, set_msg]

metadata:
  file_format: 1
